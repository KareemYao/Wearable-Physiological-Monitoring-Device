# Keil uVision project HAL_ADS_SPI.uvprojx, settings and files
target HAL_ADS_SPI (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G030C8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: HAL_ADS_SPI +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G030xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g030xx.s
  group Application/User/Core
    ../Core/Src/: bsp_ads1292.c bsp_usart_dma.c main.c gpio.c adc.c dma.c spi.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
    ../Core/Inc/: bsp_ads1292.h bsp_usart_dma.h
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
software components: CMSIS:CORE 4.3.0
